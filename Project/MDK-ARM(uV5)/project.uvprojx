# Keil uVision project project.uvprojx, settings and files
target Flash (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MultiRotor_4 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\User\usb_virture_com;..\..\User;..\..\User\bsp;..\..\User\Driver\IIC;..\..\User\Driver\LED;..\..\User\Driver\TIM;..\..\User\Driver\Delay;..\..\User\Driver\UART;..\..\User\Driver\MOTOR;..\..\User\Driver\PWM_IN;..\..\User\Driver\EEPROM;..\..\User\Algorithm\Algorithm_filter;..\..\User\Algorithm\Algorithm_math;..\..\User\Algorithm\Algorithm_sqLite;..\..\User\Algorithm\Algorithm_quaternion;..\..\User\Function\MultiRotor_rc;..\..\User\Function\MultiRotor_app;..\..\User\Function\MultiRotor_ahrs;..\..\User\Function\MultiRotor_radio;..\..\User\Function\MultiRotor_control;..\..\User\Driver\STMFLASH;..\..\User\Function\MultiRotor_altitute;..\..\User\Modules\Modules_ultrasonic;..\..\User\ANO_DT;..\..\User\Driver\Modules_hmc5883;..\..\User\Driver\Modules_mpu6050;..\..\User\Driver\Modules_ms5611;..\..\User\Driver\Modules_oled;..\..\User\Driver\Modules_ultrasonic;..\..\User\Function\Heigh
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group StdLIB
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_exti.c
  group HARDWARE
    ../../User/Driver/LED/: led.c
    ../../User/Driver/IIC/: I2C.c
    ../../User/Driver/TIM/: time.c
    ../../User/Driver/MOTOR/: moto.c
    ../../User/Driver/UART/: usart.c
    ../../User/Driver/Delay/: delay.c
    ../../User/Driver/EEPROM/: eeprom.c
    ../../User/Driver/PWM_IN/: pwm_in.c
    ../../User/Driver/STMFLASH/: stmflash.c
    ../../User/Driver/Modules_mpu6050/: mpu6050.c
    ../../User/Driver/Modules_ms5611/: MS5611.c
    ../../User/Driver/Modules_ultrasonic/: Ultrasonic.c
    ../../User/Driver/Modules_hmc5883/: hmc5883.c
  group ALGORITHM
    ../../User/Algorithm/Algorithm_filter/: Algorithm_filter.c
    ../../User/Algorithm/Algorithm_math/: Algorithm_math.c mymath.c
    ../../User/Algorithm/Algorithm_sqLite/: Algorithm_sqLite.c
    ../../User/Algorithm/Algorithm_quaternion/: Algorithm_quaternion.c
  group FUNCTION
    ../../User/Function/MultiRotor_rc/: MultiRotor_rc.c
    ../../User/Function/MultiRotor_app/: MultiRotor_app.c
    ../../User/Function/MultiRotor_ahrs/: MultiRotor_ahrs.c
    ../../User/Function/MultiRotor_radio/: MultiRotor_radio.c
    ../../User/Function/MultiRotor_control/: MultiRotor_control.c
    ../../User/Function/MultiRotor_altitute/: MultiRotor_altitute.c
    ../../User/Function/Heigh/: height_ctrl.c
    ../../User/ANO_DT/: ANO_DT.c
  group USER
    ../../User/: main.c stm32f10x_it.c
target CpuRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_CpuRAM.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\User\bsp;..\..\User\usb_virture_com;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ExtSRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: output +hex
  AfterMake: CopyHex_ExtSRAM.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
